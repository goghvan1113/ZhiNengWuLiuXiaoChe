# Keil uVision project Car.uvprojx, settings and files
target Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BSP_INIT;..\HARDWARE\chassis_motor;..\HARDWARE\duoji;..\HARDWARE\encoder;..\HARDWARE\fifo;..\HARDWARE\Gyroscope;..\HARDWARE\PID;..\HARDWARE\TIMER;..\HARDWARE\TRACKING;..\HARDWARE;..\USMART;..\HARDWARE\QRCode\gm65_scan;..\HARDWARE\QRCode\OLED;..\HARDWARE\Servo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../HARDWARE/encoder/: SpeedSolving.c
    ../HARDWARE/: CarRun.c RunAllPoint.c
    ../HARDWARE/Gyroscope/: yaw.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BSP_INIT/: BSP_Init.c
    ../HARDWARE/chassis_motor/: motor.c
    ../HARDWARE/duoji/: dj.c
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/fifo/: data_fifo.c usart1.c
    ../HARDWARE/Gyroscope/: gyroscope.c
    ../HARDWARE/PID/: PIDController.c SpeedControl.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TRACKING/: tracking.c
    ../HARDWARE/QRCode/gm65_scan/: gm65.c
    ../HARDWARE/QRCode/OLED/: oled.c
  group Servo
    ../HARDWARE/Servo/: servo.c ramp.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c
